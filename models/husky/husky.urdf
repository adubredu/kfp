Commit message: able to open top drawer with both joint angles and handle pose

File: models/husky/husky.urdf (robot description, URDF)
Before this commit: robot husky_robot, 13 links, 12 joints
Links:
- link platform_link: geometry visual box size=0.3 0.3 0.3
